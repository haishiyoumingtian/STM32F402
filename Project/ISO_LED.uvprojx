# Keil uVision project ISO_LED.uvprojx, settings and files
target ISO_LED (ARM-ADS)
  device: STM32F042C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ISO_LED +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F042,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\include;..\Libraries\CMSIS\source\startup;..\Libraries\FWLib\inc;..\User\inc;..\User\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group StartUp
    ../Libraries/CMSIS/source/startup/arm/: startup_stm32f042.s
  group CMSIS
    ../Libraries/CMSIS/source/: system_stm32f0xx.c
    ../User/src/: stm32f0xx_it.c
  group FWLib
    ../Libraries/FWLib/src/: stm32f0xx_rcc.c stm32f0xx_gpio.c stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../User/src/: led.c main.c rcc.c usart.c tim.c can.c adc.c delay.c motor_ctrl.c
    ../User/inc/: motor.c
